# IAR project server.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxD ST STM32F10xxD
  ICCARM.CCDefines: IAR_ARM_CM3; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc\drv; ..\inc\app; ..\inc\os; ..\inc\st_lib; ..\inc\dsp_lib; ..\inc\sys; ..\inc\tasks; ..\inc\lwip; ..\inc\lwip\arch; ..\inc\lwip\ipv4; ..\src\lwip
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ..\inc\os
  OBJCOPY.OOCOutputFile: server.bin
  ILINK.IlinkOutputFile: server.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration WaterMonitor (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\Source\include; ; ..\Common\include; STM32F10x_StdPeriph_Driver\inc; CMSIS\CM3\DeviceSupport\ST\STM32F10x; CMSIS\CM3\CoreSupport; ..\inc; ..\inc\gprs; ..\inc\hal; STM32F10x_DSP_Lib\inc
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  group drv
    ../src/drv/: adc.c cmd.c iic.c key.c msginfo.c network.c spi.c
  group lib
    ../lib/: Landlib.a
  group lwip
    ../src/lwip/: enc28j60.c etharp.c ethernetif.c netconf.c sys_arch.c
  group sys
    ../src/sys/: stm32f10x_it.c stm32f10x_vector.c system_stm32f10x.c
  group tasks
    ../src/tasks/: cmdTask.c landcmd.c main.c miscTask.c tcpTask.c w108cmd.c w108Task.c
