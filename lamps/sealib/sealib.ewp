# IAR project sealib.ewp, settings and files
configuration MB851 (ARM, debug)
  General.OGChipSelectEditMenu: EM357 SiliconLaboratories EM357
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ENABLE_GATEWAY; NULL_BTL; CORTEXM3_EM357
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\inc\hal; ..\inc\hal\cortexm3; ..\inc\stack; ..\inc\util; ..\inc\car
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/stm32w108/board/MB851.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; PHY_EM3XX; BOARD_MB851; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE; NULL_BTL
  AARM.AUserIncludes: ..\..\; ..\..\STACK\; ..\..\HAL\; ..\; ..\inc\hal
  OBJCOPY.OOCOutputFile: gateway.s37
  ILINK.IlinkOutputFile: gateway.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: icf/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
configuration MB850 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32W108HB ST STM32W108HB
  ICCARM.CCDefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board/MB850.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_EM3XX; BOARD_MB850; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\
  AARM.ADefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board/MB850.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_EM3XX; BOARD_MB850; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sink.s37
  postbuild: "..\..\..\tool\em3xx\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: sink.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
  group arch
    arch/: bootloader-interface-app.c bootloader-interface-standalone.c bootloader-interface.c cstartup-iar-common.c ember-configuration.c faults.s79 isr-stubs.s79
  group hal
    hal/: button.c buzzer.c crc.c diagnostic.c endian.c led.c mpu.c random.c sim-eeprom.c sleep.c token-def.c token.c
  group lamp
    lamp/: console.c flash.c fragment.c frame.c lamp.c mem.c msg.c serial.c spi.c table.c ticker.c uart.c
  group util
    util/: ami-inter-pan.c form-and-join-node-adapter.c form-and-join-node-callbacks.c form-and-join.c node.c security-address-cache.c security-common.c source-route-common.c source-route.c trust-center.c
