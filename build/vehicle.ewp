# IAR project vehicle.ewp, settings and files
configuration MB851 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32W108 ST STM32W108
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\inc; ..\inc\hal; ..\inc\hal\cortexm3; ..\inc\stack; ..\inc\util; ..\inc\car
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board/MB851.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_EM3XX; BOARD_MB851; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE
  AARM.AUserIncludes: ..\..\; ..\..\STACK\; ..\..\HAL\; ..\
  OBJCOPY.OOCOutputFile: vehicle.s37
  postbuild: "em3xx_convert.exe" "Exe\vehicle.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: vehicle.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: icf/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
configuration MB850 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board/MB850.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_EM3XX; BOARD_MB850; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NULL_BTL; BOARD_HEADER="hal/micro/cortexm3/stm32w108/board/MB850.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; CORTEXM3; CORTEXM3_STM32W108; PHY_EM3XX; BOARD_MB850; CONFIGURATION_HEADER="app/sensor/sensor-configuration.h"; SINK_APP; EMBER_SERIAL1_MODE=EMBER_SERIAL_FIFO; EMBER_SERIAL1_TX_QUEUE_SIZE=128; EMBER_SERIAL1_RX_QUEUE_SIZE=16; EMBER_SERIAL0_DEBUG; SCAN_DEBUG_PRINT_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sink.s37
  postbuild: "..\..\..\tool\em3xx\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: sink.out
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/stm32w108/iar-cfg.icf
configuration Debug (ARM, debug)
  as the first configuration, except:
  AARM.AUserIncludes: ..\..\; ..\..\STACK\; ..\..\HAL\; ..\; ..\inc\hal
  OBJCOPY.OOCOutputFile: ledlamp.s37
  postbuild: "em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: ledlamp.out
configuration sensor (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: ledlamp.s37
  postbuild: "..\..\bin\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: ledlamp.out
  group docs
    ../../docs/: cmd.txt ctrl_cmd.txt lamp_log.txt ledlamp开发文档.doc server_log.txt 小车通信协议.doc 测试命令.txt
  group lamp
    ../src/lamp/: adc.c callback.c common.c micro.c mobile.c pwm.c vehicle.c
  group lib
    ../lib/: alarm-library.a binding-table-library.a cbke-stub-library.a end-device-bind-stub-library.a hal-library.a sealib.a security-library-core.a security-library-link-keys.a zigbee-pro-stack.a
  group main
    ../src/main/: command.c exception.c incoming.c ledlamp.c network.c sensor.c sink.c sysinfo.c timevent.c
